# IAR project pr01_Node_Alive.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\libs
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: pr01_Node_Alive.srec
  ILINK.IlinkOutputFile: pr01_Node_Alive.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: deviceType.h main.c nRF_Configuration.h uart_config.h
  group libs
    ../../libs/: bme280.c bme280.h clock_led.c clock_led.h cmdutils.c cmdutils.h commonTypes.h eeprom.h i2c_stm8x.c i2c_stm8x.h nRF.c nRF.h nRF_IRQ_stm8x.c nRF_IRQ_stm8x.h nRF_RegText.c nRF_RegText.h nRF_SPI.c nRF_SPI.h nRF_Tx.c nRF_Tx.h rf_protocol.c rf_protocol.h spi_stm8x.c spi_stm8x.h uart.c uart.h uart_stm8x.c uart_stm8x.h
